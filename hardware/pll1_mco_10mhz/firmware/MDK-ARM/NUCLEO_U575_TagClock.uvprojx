# Keil uVision project NUCLEO_U575_TagClock.uvprojx, settings and files
target NUCLEO_U575_TagClock (6140000::V6.14::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x30000000,0x030000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: NUCLEO_U575_TagClock +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32U575xx
  c include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  group Application
    ../Core/Src/: main.c tag_clock.c system_stm32u5xx.c
    ./: startup_stm32u575xx.s
  group Headers
    ../Core/Inc/: tag_clock_config.h tag_clock.h tag_clock_hw.h
